Commit message: All of my work was wrong.

File: World/models/box0.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link base_link: mass 100.0 -> 0.1
